# Keil uVision project template.uvprojx, settings and files
target default (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app_v110 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=2
  c misc: --no-multibyte-chars
  c include: ..\common;..\common\drivers;.\std_periph_driver\inc;.\user;.\mycode;.\mydrive
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c system_stm32f10x.c stm32f10x_it.h stm32f10x_it.c
  group startup
    ./startup/: startup_stm32f10x_md.s
  group std_periph_driver
    ./std_periph_driver/inc/: misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./std_periph_driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group mycode
    ./mycode/: struct_init.c struct_init.h
    ../common/: ota_info.c
  group mydrive
    ./mydrive/: my_usart.c my_usart.h
    ../common/drivers/: MySPI.c W25Q64.c
